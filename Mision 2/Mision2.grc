options:
  parameters:
    author: estudiante
    generate_options: qt_gui
    id: Mision2
    output_language: python
    title: TX
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud señal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia TX [dB]
    start: '0'
    step: '1'
    stop: '30'
    value: '20'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Centro [MHZ]
    start: '50'
    step: '0.5'
    stop: '2200'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '12500000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: A
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: fc*1e6
    fftsize: '16384'
    name: '"Estudio frecuencia"'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc*1e6
    fftsize: '16384'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1e6
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc*1e6
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_const_source_x_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
